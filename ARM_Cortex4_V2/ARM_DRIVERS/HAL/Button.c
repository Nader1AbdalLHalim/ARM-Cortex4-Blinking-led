/**********************************************************************************************************************
 *  FILE DESCRIPTION
 *  -----------------------------------------------------------------------------------------------------------------*/
/**        \file  Button.c
 *        \brief  
 *
 *      \details  Source File for Button Module .
 *
 *
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  INCLUDES
 *********************************************************************************************************************/
#include "Std_Types.h"
#include "Button.h"
/**********************************************************************************************************************
*  LOCAL MACROS CONSTANT\FUNCTION
*********************************************************************************************************************/

/**********************************************************************************************************************
 *  LOCAL DATA 
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  GLOBAL DATA
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  LOCAL FUNCTION PROTOTYPES
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  LOCAL FUNCTIONS
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  GLOBAL FUNCTIONS
 *********************************************************************************************************************/

/******************************************************************************
 * \Syntax          : Button_State Button_GetState(Button_ChannelType ButtonChannel, Button_AttachType ButtonAttach)
 * \Description     : Function to Get Status Specific Button .
 *
 * \Sync\Async      : Synchronous
 * \Reentrancy      : Reentrant
 * \Parameters (in) : ButtonChannel - Button Id.
 *					  ButtonAttach  - The connection type (PULL_UP or PULL_DOWN)
 * \Parameters (out): None
 * \Return value:   : None
 *******************************************************************************/
Button_State Button_Read(uint32 Port,Button_PinType ButtonChannel, Button_AttachType ButtonAttach)
{
	Dio_LevelType level = DIO_LEVEL_LOW;
	
	Button_State button_Value ;
	
	if (ButtonAttach == PullUp)
	{
		level = HIGH;
	}
		
	else if (ButtonAttach == PullDown)
	{
		level = LOW;
	}
		
	
	if (Dio_ReadChannel(Port,ButtonChannel) == level)
	{
		/* Delay to avoid bouncing */
		int i;
		for(i=0; i<1000; i++);
		
		if (Dio_ReadChannel(Port,ButtonChannel) == level)
		{
			button_Value = BUTTON_RELEASED;
		}
		else
		{
			button_Value = BUTTON_PRESSED;
		}
	}
	else
	{
		
		button_Value =  BUTTON_PRESSED;
	}
	
	return button_Value;
}
/**********************************************************************************************************************
 *  END OF FILE: Button.c
 *********************************************************************************************************************/
