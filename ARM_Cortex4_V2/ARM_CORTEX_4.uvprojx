# Keil uVision project ARM_CORTEX_4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM_CORTEX_4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\ARM_DRIVERS\APPLICATION1\app_inc;.\ARM_DRIVERS\COMMON1;.\ARM_DRIVERS\CONFIG1\CONFIG_inc;.\ARM_DRIVERS\HAL\HAL_inc;.\ARM_DRIVERS\ProjectFiles\ProjectFiles_inc;.\ARM_DRIVERS\MCAL\MCAL_inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./ARM_DRIVERS/APPLICATION1/: APP.c
  group CONFIG
    ./ARM_DRIVERS/CONFIG1/: Dio_Cfg.c IntCtrl_Cfg.c Port_Cfg.c SysTick_Cfg.c
  group HALL
    ./ARM_DRIVERS/HAL/: Button.c Led.c
  group MCAL
    ./ARM_DRIVERS/MCAL/: Dio.c IntCtrl.c Port.c SysTick.c
  group PROJECT_FILES
    ./ARM_DRIVERS/ProjectFiles/: Blink.c Input.c System.c UserTimer.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
